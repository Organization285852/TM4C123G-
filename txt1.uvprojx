# Keil uVision project txt1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123FH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: txt1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: .\inc;.\driverlib;.\HAL;.\user;.\moudle;.\FatFS\src;.\app
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./user/: main.c includes.h
    ./driverlib/rvmdk/: driverlib.lib
  group TM4C123G_LIB
    ./driverlib/: gpio.c sysctl.c i2c.c pwm.c timer.c uart.c systick.c
  group driver
    ./HAL/: usart.c hal_i2c.c hal_pwm.c hal_timer.c hal_pwm_in.c bee.c
    ./moudle/: delay.c
  group moudle
    ./moudle/: px4flow.c mymath.c mpu6050.c ak8975.c led.c ultrasonic.c ms5611.c rc.c parameter.c drv_w25qxx.c
  group fatfs
    ./FatFS/src/: ff.c diskio.c
  group App
    ./app/: imu.c ctrl.c filter.c scheduler.c height_ctrl.c init.c bluetooth.c data_transfer.c distance.c autofly.c tracking.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
